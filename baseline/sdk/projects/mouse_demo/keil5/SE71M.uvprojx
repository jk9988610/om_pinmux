# Keil uVision project SE71M.uvprojx, settings and files
target SE71M (6160000::V6.16::ARMCLANG)
  device: OM6239 Onmicro
  pack: Onmicro.OM6239.1.0.0
  cpu: IROM(0x00000000,0x100000) IRAM(0x20000000,0x3000) CPUTYPE("Cortex-M0") CLOCK(48000000) ELITTLE
  output: SE71M +hex
  AfterMake: fromelf.exe --bin --output "@L.bin" "#L"
  AfterMake: fromelf.exe -c --output ".\_build\@L.dis" "#L"
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 v6Lto=1 wLevel=3
  c define: CONFIG_OM6239=1,CONFIG_HARDWARE_VERSION=1,CONFIG_BOARD_OM6239_EVB=1,CONFIG_EVT=1,CONFIG_EXBLE2=1,CONFIG_PM=1,CONFIG_OM_PRINTF=0,CONFIG_OM_ASSERT=0,CONFIG_MOUSE_AUTO_CIRCLE=0,
  c include: ../config;../config;../main;../periph;../../../common/includes;../../../hal/CMSIS/Core/Include;../../../hal/device/include;../../../hal/driver/include;../../../hal/driver/common;../../../components/evt;../../../components/exble2/includes;../../../components/exble2/port;../../../components/tinycrypt/include;../../../components/om_cfg;../../../components/pm;../../../bsp;..\..\..\mode_24g;..\..\..\mode_usb;..\..\..\components\cherry_usb\class;..\..\..\components\cherry_usb\common;..\..\..\components\cherry_usb\core;..\..\..\components\cherry_usb;..\flash
  asm define: as above
  asm include: ../config;../config;../main;../periph;../../../common/includes;../../../hal/CMSIS/Core/Include;../../../hal/device/include;../../../hal/driver/include;../../../hal/driver/common;../../../components/evt;../../../components/exble2/includes;../../../components/exble2/port;../../../components/tinycrypt/include;../../../components/om_cfg;../../../components/pm;../../../bsp
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0xc000
  scatter file: ../../../hal/device/om6239/ARM/om6239_ac6.sct
  link misc: --diag_suppress=L6314 --diag_suppress=L6312  ../../../components/exble2/stack/exble2.lib
  group main
    ../main/: main.c ex2_app_mouse.c ex2_profile_hid_mouse.c mouse_hw.c
  group periph
    ../periph/: key_io.c led.c lvd.c sensor_type_check.c sensor.c time_delay.c user_config.c mode_ind.c userdefined_key_20260724.o board_features.h
  group device
    ../../../hal/device/om6239/: system_om6239.c
    ../../../hal/device/om6239/GCC/: startup_om6239.S system_om6239_gnu.S
  group driver
    ../../../hal/driver/common/: drv_gpio.c drv_aes128.c drv_rtc.c drv_timer.c drv_rf.c drv_flash.c drv_rcc.c drv_wdt.c
    ../../../hal/driver/om6239/: drv_isr.c drv_pmu.c drv_senscan.c drv_encoder.c
  group evt
    ../../../components/evt/: evt.c
  group exble2
    ../../../components/exble2/port/: ex2_hal_om62xx.c
    ../../../components/tinycrypt/src/: ecc.c ecc_dh.c
  group mode_24g
    ../../../mode_24g/: main_24g.c sleep.c rf_data_process.c rf_fcc.c rf_fcc_key_ctrl.c rf_protocol_20260704.o
  group mode_usb
    ../../../mode_usb/: main_usb.c hal_usb_decs.c hid_process.c usb_user_process.c
  group flash
    ../flash/: flash.c flash_process.c
